# Keil uVision project empty_mspm0g3507_nortos_keil.uvprojx, settings and files
target empty_mspm0g3507 (6240000::V6.24::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20100000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) XRAM(0x20200000,0x00008000) XRAM2(0x20300000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: empty_mspm0g3507 +hex
  BeforeMake: cmd.exe /C "$Psyscfg_generate.bat"
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0G3507__
  c include: E:\NUEDC\mspm0_sdk_2_02_00_05\source\third_party\CMSIS\Core\Include,E:\NUEDC\mspm0_sdk_2_02_00_05\source
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT6: RAM 0x20200000 size 0x8000
  memory RVCT7: RAM 0x20300000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x8000
  scatter file: .\mspm0g3507.sct
  group Application
    ./: empty_mspm0g3507.c competition_build.h app_config.h
  group Documentation
    ./: README.md H2026_BRINGUP.md openmv_ball_tracker.py TUNING_GUIDE.md X42S_INTEGRATION.md
  group Competition Runtime
    ./: competition_runtime.c competition_runtime.h competition_registry.c competition_registry.h competition_selector.c competition_selector.h competition_safety.c competition_safety.h competition_ui.c competition_ui.h competition_task.h
  group Tasks
    ./: task2.c task2.h task2_config.h
  group Control
    ./: ball_control.c ball_control.h motion_control.c motion_control.h pid.c pid.h
  group Platform
    ./: control_scheduler.c control_scheduler.h chassis_model.c chassis_model.h chassis_config.h
  group Drivers
    ./: ball_vision.c ball_vision.h rod_actuator.c rod_actuator.h app_io.c app_io.h motor.c motor.h track.c track.h encoder.c encoder.h imu.c imu.h power_switch.c power_switch.h zdt_stepper.c zdt_stepper.h lcd_display.c lcd_display.h
  group Generated
    ./: empty_mspm0g3507.syscfg startup_mspm0g350x_uvision.s ti_msp_dl_config.h ti_msp_dl_config.c
  group Driverlib
    E:/NUEDC/mspm0_sdk_2_02_00_05/source/ti/driverlib/lib/keil/m0p/mspm0g1x0x_g3x0x/: driverlib.a
